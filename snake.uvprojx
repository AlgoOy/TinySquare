# Keil uVision project snake.uvprojx, settings and files
target snake (6190000::V6.19::ARMCLANG)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: snake +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\RTE\Device\STM32L496VETx\STCubeGenerated\User;.\RTE\Device\STM32L496VETx\STCubeGenerated\Bsp\Inc;.\RTE\Device\STM32L496VETx\STCubeGenerated\User\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496VETx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496VETx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group User
    ./RTE/Device/STM32L496VETx/STCubeGenerated/tiny_square/example/snake/: body.c fruit.c logo.c snake.c snake_v2.c
  group Bsp
    ./RTE/Device/STM32L496VETx/STCubeGenerated/Bsp/Src/: lcd.c spi.c key.c
  group gfx
    ./RTE/Device/STM32L496VETx/STCubeGenerated/tiny_square/graphics/: layer_management.c tnsq_graphics_controller.c tnsq_layer.c tnsq_stage.c tnsq_init.c tnsq_disp.c
  group event
    ./RTE/Device/STM32L496VETx/STCubeGenerated/tiny_square/event/: event_management.c tnsq_event_controller.c
target snake_v2 (6190000::V6.19::ARMCLANG)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: as above
  output: snake +hex
  c flags: as above
  c include: .\RTE\Device\STM32L496VETx\STCubeGenerated\User;.\RTE\Device\STM32L496VETx\STCubeGenerated\Bsp\Inc;.\RTE\Device\STM32L496VETx\STCubeGenerated\User\Inc;.\RTE\Device\STM32L496VETx\STCubeGenerated\tiny_square;.\RTE\Device\STM32L496VETx\STCubeGenerated\tiny_square\graphics;.\RTE\Device\STM32L496VETx\STCubeGenerated\tiny_square\event;.\RTE\Device\STM32L496VETx\STCubeGenerated\tiny_square\example\snake
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: Acceleration:Arm-2D Extras:Controls 1.4.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 1.3.1, Acceleration:Arm-2D Helper:Display Adapter 1.5.10, Acceleration:Arm-2D Helper:PFB 1.6.7, Acceleration:Arm-2D Helper:RTOS Helper 1.0.0, Acceleration:Arm-2D Helper:Scene 1.1.8, Acceleration:Arm-2D:Alpha-Blending 1.1.3, Acceleration:Arm-2D:Core 1.1.3, Acceleration:Arm-2D:Transform 1.1.3, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, Utilities:perf_counter:Core 2.2.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:Startup 1.3.1, RTOS:kernel 3.1.5
